# Keil uVision project Final_Project_ASM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Final_Project_ASM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay_1ms.a51 ADCread.a51 DPTRfilter.a51 InitLCD.a51 main.a51 NrDisplay.a51 Sendinstr.a51 TempStringDisp.a51 Err_Display.a51 Display_up_nr.a51 DPTRfilter_ref.a51 Display_down_nr.a51 Test_compare.a51 delay_10ms.a51
