# Keil uVision project Final_Project_C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Final_Project_C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC_Read.c Delay_ms.c Display_number.c Init_Lcd.c Main.c Test_Relay.c
